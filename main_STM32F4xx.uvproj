# Keil uVision project main_STM32F4xx.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: main +hex
  c flags: Optim=1 OneElfS=1
  c define: _KEIL,_HSE_BYPASS_ON, STM32F407xx, _HSE_CLK=25000
  c include: .\src;..\EmbSysLib\Lib\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Src
    ../EmbSysLib/Lib/Src/: lib.cpp
    ./Src/: main.cpp
    ../EmbSysLib/Lib/Src/Module/: RTOS.cpp
    ../EmbSysLib/Lib/Src/Hardware/MCU/STM32F4xx/Sys/Keil/: RTOScontext.s startup_stm32f4xx.s
